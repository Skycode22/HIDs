File: TrashTruck/PCB/switchplate/switchplate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 352.4 x 85.8 mm, 0 parts

Commit message: app update
Other:
- outline, holes or cut-outs redrawn
